options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: c4fm_tx
    output_language: python
    run_options: run
    title: c4fm_tx
  states: {}

blocks:
- name: lo_freq
  id: variable_qtgui_range
  parameters:
    label: lo freq
    orient: Qt.Vertical
    start: '80000000'
    step: '100'
    stop: '6000000000'
    value: '155194500'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '38400'
  states: {}
- name: tx_db
  id: variable_qtgui_range
  parameters:
    label: tx db
    min_len: '359'
    orient: Qt.Vertical
    start: '0'
    step: '0.25'
    stop: '89.75'
    value: '10'
  states: {}
- name: tx_file
  id: variable_qtgui_entry
  parameters:
    label: tx file
    type: string
    value: /home/hao/wrk/my_adc/nh7020_git/gr-iio.bk/iio-examples/test_da/c4fm_music2.pcm
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_0_1
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_0_1_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2*3.1415926*600/samp_rate
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: tx_file
    repeat: 'True'
    type: float
  states: {}
- name: blocks_patterned_interleaver_0
  id: blocks_patterned_interleaver
  parameters:
    pattern: '[0,1,2,3]'
    type: float
  states: {}
- name: blocks_patterned_interleaver_0_0
  id: blocks_patterned_interleaver
  parameters:
    pattern: '[0,1]'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    ignoretag: 'False'
    samples_per_second: '4800'
    type: float
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    ignoretag: 'False'
    samples_per_second: '4800'
    type: float
  states: {}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    ignoretag: 'False'
    samples_per_second: '19200'
    type: float
  states: {}
- name: blocks_throttle_0_0_1
  id: blocks_throttle
  parameters:
    ignoretag: 'False'
    samples_per_second: '4800'
    type: float
  states: {}
- name: blocks_throttle_0_0_1_0
  id: blocks_throttle
  parameters:
    ignoretag: 'False'
    samples_per_second: '4800'
    type: float
  states: {}
- name: blocks_throttle_0_0_2_1
  id: blocks_throttle
  parameters:
    ignoretag: 'False'
    samples_per_second: '38400'
    type: float
  states: {}
- name: blocks_throttle_0_0_2_1_0
  id: blocks_throttle
  parameters:
    ignoretag: 'False'
    samples_per_second: '38400'
    type: complex
  states: {}
- name: howto_my_filter001_0
  id: howto_my_filter001
  parameters: {}
  states: {}
- name: howto_my_filter003_0
  id: howto_my_filter003
  parameters: {}
  states: {}
- name: iio_fmcomms2_sink_0_0
  id: iio_fmcomms2_sink
  parameters:
    attenuation1: tx_db
    auto_filter: 'True'
    bandwidth: '300000'
    buffer_size: '0x8000'
    cyclic: 'False'
    frequency: lo_freq
    rf_port_select: '''A'''
    samplerate: '2304000'
    tx1_en: 'True'
    tx2_en: 'False'
    uri: 192.168.2.1
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.1'
    bw: samp_rate
    fc: lo_freq
    fftsize: '1024'
    grid: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: lo_freq
    fftsize: '1024'
    grid: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '60'
    taps: ''
    type: ccf
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_throttle_0_0, '0']
- [analog_const_source_x_0_0, '0', blocks_throttle_0_0_0, '0']
- [analog_const_source_x_0_1, '0', blocks_throttle_0_0_1, '0']
- [analog_const_source_x_0_1_0, '0', blocks_throttle_0_0_1_0, '0']
- [analog_frequency_modulator_fc_0, '0', blocks_throttle_0_0_2_1_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_patterned_interleaver_0, '0', howto_my_filter001_0, '0']
- [blocks_patterned_interleaver_0_0, '0', blocks_throttle_0_0_2_1, '0']
- [blocks_throttle_0, '0', blocks_patterned_interleaver_0, '0']
- [blocks_throttle_0_0, '0', blocks_patterned_interleaver_0, '1']
- [blocks_throttle_0_0_0, '0', blocks_patterned_interleaver_0_0, '1']
- [blocks_throttle_0_0_1, '0', blocks_patterned_interleaver_0, '2']
- [blocks_throttle_0_0_1_0, '0', blocks_patterned_interleaver_0, '3']
- [blocks_throttle_0_0_2_1, '0', howto_my_filter003_0, '0']
- [blocks_throttle_0_0_2_1_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_throttle_0_0_2_1_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0_0_2_1_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0_0_2_1_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_throttle_0_0_2_1_0, '0', rational_resampler_xxx_0, '0']
- [howto_my_filter001_0, '0', blocks_patterned_interleaver_0_0, '0']
- [howto_my_filter003_0, '0', analog_frequency_modulator_fc_0, '0']
- [rational_resampler_xxx_0, '0', iio_fmcomms2_sink_0_0, '0']

metadata:
  file_format: 1
