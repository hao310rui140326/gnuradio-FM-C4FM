options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
    run_options: run
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '38400'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_0_1
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_0_1_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2*3.1415926*600/samp_rate
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/hao/wrk/my_adc/nh7020_git/gr-iio.bk/iio-examples/test_da/c4fm_music.pcm
    repeat: 'True'
    type: float
  states: {}
- name: blocks_patterned_interleaver_0
  id: blocks_patterned_interleaver
  parameters:
    pattern: '[0,1,2,3]'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    ignoretag: 'False'
    samples_per_second: '4800'
    type: float
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    ignoretag: 'False'
    samples_per_second: '4800'
    type: float
  states: {}
- name: blocks_throttle_0_0_1
  id: blocks_throttle
  parameters:
    ignoretag: 'False'
    samples_per_second: '4800'
    type: float
  states: {}
- name: blocks_throttle_0_0_1_0
  id: blocks_throttle
  parameters:
    ignoretag: 'False'
    samples_per_second: '4800'
    type: float
  states: {}
- name: blocks_throttle_0_0_2_1_0
  id: blocks_throttle
  parameters:
    ignoretag: 'False'
    samples_per_second: '38400'
    type: complex
  states: {}
- name: howto_my_filter001_0
  id: howto_my_filter001
  parameters: {}
  states: {}
- name: iio_fmcomms2_sink_0_0
  id: iio_fmcomms2_sink
  parameters:
    auto_filter: 'True'
    bandwidth: '300000'
    buffer_size: '0x8000'
    cyclic: 'False'
    frequency: '155194500'
    rf_port_select: '''A'''
    samplerate: '2304000'
    tx1_en: 'True'
    tx2_en: 'False'
    uri: 192.168.3.2
  states: {}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: '38400'
    fc: '0'
    fftsize: '8192'
    name: '"phase"'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: '2304000'
    fc: '0'
    fftsize: '8192'
    name: '"rsamp"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '60'
    taps: ''
    type: ccf
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '2'
    taps: ''
    type: fff
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_throttle_0_0, '0']
- [analog_const_source_x_0_1, '0', blocks_throttle_0_0_1, '0']
- [analog_const_source_x_0_1_0, '0', blocks_throttle_0_0_1_0, '0']
- [analog_frequency_modulator_fc_0, '0', blocks_throttle_0_0_2_1_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_patterned_interleaver_0, '0', howto_my_filter001_0, '0']
- [blocks_throttle_0, '0', blocks_patterned_interleaver_0, '0']
- [blocks_throttle_0_0, '0', blocks_patterned_interleaver_0, '1']
- [blocks_throttle_0_0_1, '0', blocks_patterned_interleaver_0, '2']
- [blocks_throttle_0_0_1_0, '0', blocks_patterned_interleaver_0, '3']
- [blocks_throttle_0_0_2_1_0, '0', qtgui_sink_x_0_0_0, '0']
- [blocks_throttle_0_0_2_1_0, '0', rational_resampler_xxx_0, '0']
- [howto_my_filter001_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_0, '0', iio_fmcomms2_sink_0_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_sink_x_0_0_0_0, '0']
- [rational_resampler_xxx_1, '0', analog_frequency_modulator_fc_0, '0']

metadata:
  file_format: 1
