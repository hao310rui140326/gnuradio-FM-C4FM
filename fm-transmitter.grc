options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: fm_station
  id: variable
  parameters:
    value: '155194500'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2304000'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: '48000'
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: int(samp_rate / 8)
    tau: '75e-6'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/hao/wrk/my_adc/nh7020_git/gr-iio.bk/iio-examples/star_wars.wav
    repeat: 'True'
  states: {}
- name: iio_fmcomms2_sink_0_0
  id: iio_fmcomms2_sink
  parameters:
    auto_filter: 'False'
    bandwidth: '300000'
    buffer_size: '0x8000'
    cyclic: 'False'
    frequency: fm_station
    rf_port_select: '''A'''
    samplerate: samp_rate
    tx1_en: 'True'
    tx2_en: 'False'
    uri: 192.168.3.2
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    rate: '1'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '8'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_nbfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_0, '0', analog_nbfm_tx_0, '0']
- [rational_resampler_xxx_0, '0', iio_fmcomms2_sink_0_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
